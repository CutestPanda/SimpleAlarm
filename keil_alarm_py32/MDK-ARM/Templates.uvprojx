# Keil uVision project Templates.uvprojx, settings and files
target PY32F003x4_Templates (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F003x4 Puya
  pack: Puya.PY32F0xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: PY32F030x6_Templates +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F003x4
  c include: ..\Inc;..\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f003xx.s
  group Application/User
    ../Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c alarm.c
  group firmware
    ../Src/: single_key_detect.c timebase.c oled.c oled_gui.c temp_sensor.c beep.c
  group Drivers/PY32F0xx_HAL_Driver
    ../PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_cortex.c py32f0xx_hal_dma.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_gpio.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_i2c.c
software components: CMSIS:CORE 5.2.0
